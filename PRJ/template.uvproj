# Keil uVision project template.uvproj, settings and files
target Template (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x4FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: template +hex
  c flags: Optim=1 wLevel=1
  c define: CCD
  c include: ..\SRC\STARTUP;..\SRC\FWLIB\DELAY;..\SRC\FWLIB\GPIO;..\SRC\FWLIB\SYS;..\SRC\FWLIB\UART;..\SRC\FWLIB\WDOG;..\SRC\FWLIB\PIT;..\SRC\USER;..\SRC\HARDWARE\LED;..\SRC\\FWLIB\RTC;..\SRC\FWLIB\DMA;..\SRC\FWLIB\FTM;..\SRC\FWLIB\LPTM;..\SRC\FWLIB\ADC;..\SRC\FWLIB\DAC;..\SRC\FWLIB\SPI;..\SRC\HARDWARE\SPIFLASH;..\SRC\HARDWARE\SPILCD;..\SRC\FWLIB\I2C;..\SRC\FWLIB\PDB;..\SRC\HARDWARE\MMA845x;..\SRC\FWLIB\CAN;..\SRC\FWLIB\FLASH;..\SRC\FWLIB\SD;..\SRC\FWLIB\TSI;..\SRC\FWLIB\ENET;..\SRC\HARDWARE\KEY;..\SRC\HARDWARE\NRF2401;..\SRC\FWLIB\CCD;..\SRC\FWLIB\MOTOR;..\SRC\FWLIB\ENCODER;..\SRC\FWLIB\SWITCH;..\SRC\FWLIB\STEER;..\SRC\FWLIB\BELL;..\SRC\FWLIB\OLED;..\SRC\FWLIB\GYROSCOPE;..\SRC\FWLIB\VISUALSCOPE
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group STARTUP
    ../SRC/STARTUP/: system_MK60DZ10.c startup_MK60DZ10.s
  group USER
    ../SRC/USER/: main.c isr.c
    ../SRC/FWLIB/CCD/: ccd.c
    ../SRC/FWLIB/MOTOR/: motor.c
    ../SRC/FWLIB/ENCODER/: encoder.c
    ../SRC/FWLIB/SWITCH/: switch.c
    ../SRC/FWLIB/STEER/: steer.c
    ../SRC/FWLIB/BELL/: bell.c
    ../SRC/FWLIB/OLED/: oled.c
    ../SRC/FWLIB/GYROSCOPE/: gyroscope.c
    ../SRC/FWLIB/VISUALSCOPE/: outputdata.c
  group FWLIB
    ../SRC/FWLIB/SYS/: sys.c
    ../SRC/FWLIB/DELAY/: delay.c
    ../SRC/FWLIB/FTM/: ftm.c
    ../SRC/FWLIB/GPIO/: gpio.c
    ../SRC/FWLIB/PIT/: pit.c
    ../SRC/FWLIB/ADC/: adc.c
    ../SRC/FWLIB/SPI/: spi.c
    ../SRC/FWLIB/TSI/: tsi.c
    ../SRC/FWLIB/UART/: uart.c
    ../SRC/FWLIB/LPTM/: lptm.c
  group HARDWARE
    ../SRC/HARDWARE/NRF2401/: nrf2401.c
  group Documentation
    ../SRC/USER/: Abstract.txt
